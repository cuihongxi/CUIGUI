# Keil uVision project CUIGUI_Demo.uvprojx, settings and files
target CUIGUI_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CUIGUI_Demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\..\..\..\CUIGUI;..\..\..\malloc;..\..\..\datastruct;..\..\..\config\lcd\TFT;..\..\..\basic;..\..\..\font;..\..\..\guimodule;..\..\..\config\SD;..\..\..\fat32;..\..\..\config;..\..\..\guimodule\BUTTON;..\..\..\guimodule\SLIDER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c gpio.c fsmc.c sdio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_sram.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group config
    ../../../config/lcd/TFT/: lcd.c
  group malloc
    ../../../malloc/: List4_Malloc.C
  group font
    ../../../font/: MicrosoftYaHeiASCII24.c cc936.c songti24.c
  group CUIGUI
    ../../../basic/: CUIGUI_LCDDRIVER.C CUIGUI_COLOR.C GUI.C
    ../../../layout/: RELATIVE_LAYOUT.C
    ../../../guimodule/BUTTON/: CUIGUI_BUTTON.C
    ../../../guimodule/SLIDER/: CUIGUI_SLIDER.C
software components: CMSIS:CORE 4.3.0
